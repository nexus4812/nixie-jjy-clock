# Repository nexus4812/nixie-jjy-clock

File README.md:

# JJY対応4桁ニキシー管時計

IN-12B ×4で24時間の `HH:MM` を表示する卓上時計。JJY（40/60kHz）で補正し、受信できない間はDS3231で時刻を保持する設計です。Wi-Fi・GPS・インターネットは使いません。Arduino IDE / CLI向けのクラシックNano互換 ATmega328P 5V/16MHzを第一候補にしています。

**現在：回路図とケース案、制御・表示・コロン・電源の全4種の基板の候補配置・配線まで。製造承認前です。** 部品の現物照合、動くファームウェア、実測、Gerberは未完了です。

次の担当者は最初に [AGENTS.md](AGENTS.md)、[control-r1記録](docs/control-board-r1.md)、[リスク](docs/risks.md) を読んでください。2026-11-08時点の詳細な引き継ぎ資料（macOS/Ubuntuの再開コマンドを含む）は `git show 4e38a86:HANDOFF.md` で参照できます。

| 開くもの | 内容 |
| --- | --- |
| [制御板KiCadプロジェクト](hardware/pcb/generated/control-board.kicad_pro) | 6ページ・54部品。100×55mm・2層の候補PCBを同梱 |
| [全体KiCadプロジェクト](hardware/schematic/generated/nixie-jjy-clock.kicad_pro) | 11ページ・166部品。HVのTBD値と保留事項を含む |
| [OpenSCADケース](enclosure/clock.scad) | 濃色木枠と真鍮前面板の形状案。現物公差・保持具は未確定 |
| [共通寸法JSON](enclosure/layout.json) | 管中心/間隔、基板/穴、電源/操作、アンテナ、前面板の隙間の正本 |
| [control-r1記録](docs/control-board-r1.md) / [HV基板r1記録](docs/hv-boards-r1.md) | 実行結果、配線条件、コネクター、残る制約 |

2026-11-08、KiCad 10.0.8 / macOSで制御板のERC 0、DRC 0、未配線0、回路図等価性の問題0を確認しました。54部品＋取り付け穴4個、219パッドを回路図と照合しています。ERC/DRCは部品定格・実機安全性・受信性能・製造可否を保証しません。保存した記録は [docs/validation/](docs/validation/README.md) にあります。

## 資料

| 資料 | 内容 |
| --- | --- |
| [要求仕様](docs/requirements.md) / [実装計画](docs/implementation-plan.md) | 必須機能、受け入れ条件、今後の作業 |
| [部品調査](docs/components.md) / [概算BOM](docs/bom.csv) | 出典と電圧/端子、未見積の価格枠 |
| [回路構成](docs/architecture.md) / [判断記録](docs/decisions.md) | 構成比較、仮計算と変更理由 |
| [リスク](docs/risks.md) / [製造の状態](manufacturing/README.md) | HV・現物・電源・調達などの保留条件 |
| [ハードウェア](hardware/README.md) / [ケース](enclosure/README.md) | 正本と生成物、再生成方法 |
| [開発環境](docs/environment.md) / [資料台帳](docs/references/README.md) | ツール、任意MCP、一次資料URLと取得履歴 |
| [ファームウェア方針](firmware/README.md) / [検査計画](tests/README.md) | ピン割り当て、未実装機能と試験項目 |
| [Phase 1履歴](docs/verification.md) / [Phase 2初版履歴](docs/phase2-review.md) | 当時の実施結果。最新状態はcontrol-r1記録を優先 |

## 最初の確認

通常の資料スクリプトはPython 3.10以降の標準ライブラリのみを使います。PCBを扱うスクリプトはKiCad 10対応の `pcbnew` が使えるPythonで実行してください。macOS/Ubuntuの具体例は `git show 4e38a86:HANDOFF.md` の7〜8節にあります。

```sh
python3 scripts/inspect_environment.py --output build/environment.json
python3 scripts/check_phase1.py
python3 scripts/generate_schematic.py --check
python3 scripts/generate_schematic.py --variant control --check
python3 scripts/check_hardware.py
python3 scripts/generate_mechanical.py --check
```

KiCad MCPの設定は今回不要でした。公式CLIと実際に存在を確認したAPIで作成・検査しています。Ubuntu上の実行、Arduinoのコンパイル/書込は未実施です。

## ファイルの扱い

```text
AGENTS.md       AI向けの設計/検査/変更管理規約（CLAUDE.mdから参照）
docs/           要求、部品、出典、判断、リスク、保存した検査記録
hardware/       回路/配置の正本と生成済みKiCad、配線セッション
enclosure/      共通寸法JSONとOpenSCAD、生成定数
firmware/       Arduino向け方針（スケッチ未作成）
scripts/        生成、CLI検査、API読戻し、配線、資料検査
tests/          検査と将来のJJY擬似入力試験の計画
manufacturing/  未製造承認の状態と今後のリリース条件
build/          一時出力と検査ログ（Git対象外）
.cache/         外部PDF・一時ツール（Git対象外、cloneには含まれない）
```

AIが回路/基板/ソフトウェア/資料を担当し、人間が購入・実装・現物確認・実測・外装製作を担当します。電子回路の予算目標は15,000〜20,000円。現在の仮BOMは送料別15,315〜26,325円で、最新候補部品の個別見積は未取得です。

## KiCad design hardware/pcb/generated_power/power-board.kicad_pcb

File hardware/README.md:

# ハードウェア元データ

最新状態は `git show 4e38a86:HANDOFF.md` と [control-r1記録](../docs/control-board-r1.md) を参照する。候補配置/配線まで作成した低電圧制御板と、TBDを含む全体回路図を分けて管理する。現物未照合・製造承認前。

| 正本/生成物 | 扱い |
| --- | --- |
| [schematic_design.py](schematic_design.py) | 全体回路の手編集元。端子接続、出典、リスク |
| [pcb/control_layout.json](pcb/control_layout.json) | 制御板の候補フットプリント、配置、配線条件、RTC禁止領域、種配線、シルク |
| [../enclosure/layout.json](../enclosure/layout.json) | 外形、厚み、穴、ケース・管・操作部・アンテナの共通寸法 |
| [schematic/generated/nixie-jjy-clock.kicad_pro](schematic/generated/nixie-jjy-clock.kicad_pro) | 全体11ページ・111部品。HV/モジュールは未確定を含む |
| [pcb/generated/control-board.kicad_pro](pcb/generated/control-board.kicad_pro) | 制御板6ページ・54部品と候補PCB。ERC/DRC/未配線/等価性の問題0 |
| [pcb/generated/board-generation.json](pcb/generated/board-generation.json) | 正本ハッシュ、ライブラリ識別子/ファイルハッシュ、配線取り込み履歴 |
| [pcb/generated/routing/](pcb/generated/routing/README.md) | 今回のDSN/SES/対応ハッシュの保存版。直接編集しない |
| [mechanical/generated/manifest.json](mechanical/generated/manifest.json) | 外形/厚み/穴だけの6枚。回路PCBではない |

表示/コロン/電源の回路PCBは候補配置・配線済み（[記録](../docs/hv-boards-r1.md)）。全体回路図166部品のうち159部品に候補フットプリントを割り当てた。現物を照合していないため、ライブラリの存在確認と全パッドのネット検査をフットプリント確定と混同しない。ソケット/管、Nano互換機、JJY端子2.5mm、HVモジュール、電池ホルダー極性、TO-92リード成形等はR04/R15で残す。

生成されたKiCadは直接編集せず、正本を変更して再生成する。回路図生成は通常のPython、PCB生成/読戻しはKiCadのPythonを使う。具体的なコマンドは `git show 4e38a86:HANDOFF.md` に集約する。検査出力は `build/phase2/` と `build/control-board/`。手元の一時ログはGitに入れず、引き継ぎに必要な検査スナップショットを `docs/validation/` に保存する。

制御板のJ41は既製降圧器からの5V入力、J42はHV/コロンの論理制御出力。12V・HV_RAW・SHDNを制御板へ引き込んでいない。装置全体のGNDは共通であり、ガルバニック絶縁はない。高電圧の部品定格・保護・放電・接触防止は未解決。

Notes on the sheet:
JJY / IN-12B ×4 / Arduino Nano 5V / DS3231
レビュー用初版：HV電圧・K155ID1保護・部品/ソケット現物・コネクター定格は未確定。通電・発注不可。
機械寸法の正本：enclosure/layout.json。制御基板は候補配置・現物未照合。HV回路は別基板・保留。

Parts:
C1: 100u_25V; CP_Radial_D8.0mm_P3.50mm
C2: 100n_50V; C_0805_2012Metric
D1: 1N5819; D_DO-41_SOD81_P10.16mm_Horizontal
F1: FUSE_T1A_TBD; Fuseholder_Clip-5x20mm_Bel_FC-203-22_Lateral_P17.80x5.00mm_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
J1: 12V_DC_INPUT; JST_VH_B2P-VH_1x02_P3.96mm_Vertical
J2: HV_RAW_GUARDED_TP; PhoenixContact_MSTBVA_2,5_2-G-5,08_1x02_P5.08mm_Vertical
J43: TO_CONTROL_J41; PinHeader_1x02_P2.54mm_Vertical
J44: FROM_CONTROL_J42; PinHeader_1x03_P2.54mm_Vertical
J47: TO_BUCK_MODULE; PinHeader_1x03_P2.54mm_Vertical
J48: TO_HV_MODULE_LV; PinHeader_1x03_P2.54mm_Vertical
J49: FROM_HV_MODULE; PhoenixContact_MSTBVA_2,5_2-G-5,08_1x02_P5.08mm_Vertical
J60: HV_TO_DIGIT0; PhoenixContact_MSTBVA_2,5_2-G-5,08_1x02_P5.08mm_Vertical
J61: HV_TO_DIGIT1; PhoenixContact_MSTBVA_2,5_2-G-5,08_1x02_P5.08mm_Vertical
J62: HV_TO_DIGIT2; PhoenixContact_MSTBVA_2,5_2-G-5,08_1x02_P5.08mm_Vertical
J63: HV_TO_DIGIT3; PhoenixContact_MSTBVA_2,5_2-G-5,08_1x02_P5.08mm_Vertical
J64: HV_TO_COLON; PhoenixContact_MSTBVA_2,5_2-G-5,08_1x02_P5.08mm_Vertical
J65: COLON_ENABLE_OUT; PinHeader_1x02_P2.54mm_Vertical
JP2: HV_ARM_NORMALLY_OPEN; PinHeader_1x02_P2.54mm_Vertical
Q1: MPSA42; TO-92_Inline_Wide
R1: 2k2_0.25W; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 4k7; R_0805_2012Metric
R3: 100k; R_0805_2012Metric
R4, R5: 110k_0.5W_HV; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal

Connections:
5V_BUCK: J43.1, J47.3
12V_FUSED: D1.2 (A), F1.2
12V_HV: J48.1, JP2.2, R1.1
12V_IN: F1.1, J1.1
12V_PROTECTED: C1.1, C2.1, D1.1 (K), J47.1, JP2.1
COLON_ENABLE: J44.3, J65.2
GND: C1.2, C2.2, J1.2, J2.2, J43.2, J44.1, J47.2, J48.2, J49.2, J60.2, J61.2, J62.2, J63.2, J64.2, J65.1, Q1.1 (E), R3.2, R5.2
HV_BASE: Q1.2 (B), R2.2, R3.1
HV_BLEED_MID: R4.2, R5.1
HV_ENABLE: J44.2, R2.1
HV_RAW: J2.1, J49.1, J60.1, J61.1, J62.1, J63.1, J64.1, R4.1
HV_SHDN: J48.3, Q1.3 (C), R1.2

Notes on the sheet:
電源・保護・HV停止制御
市販絶縁12V DCのみ。JP1を外してUSB書込。JP2は通常未挿入。HV部はR01/R02/R06未解決・通電不可。
同名のネットラベルは階層を越えて接続。未確定値/TBDは発注不可。端子配置はSources欄を参照。

Board: 2 copper layers, 90.0 x 60.0 mm, 30 parts (0 on the bottom side), 12 nets.

Other parts of the board:
H1, H2, H3, H4: NPTH_DRAFT; MountingHole_3.2mm_M3
H5, H6: NPTH_DRAFT; MountingHole_2.2mm_M2

## KiCad design hardware/pcb/generated_colon/colon-board.kicad_pcb

Notes on the sheet:
JJY / IN-12B ×4 / Arduino Nano 5V / DS3231
レビュー用初版：HV電圧・K155ID1保護・部品/ソケット現物・コネクター定格は未確定。通電・発注不可。
機械寸法の正本：enclosure/layout.json。制御基板は候補配置・現物未照合。HV回路は別基板・保留。

Parts:
J30: COLON_HV_GUARDED; PhoenixContact_MSTBVA_2,5_2-G-5,08_1x02_P5.08mm_Vertical
J31: COLON_ENABLE_LV; PinHeader_1x02_P2.54mm_Vertical
NE1, NE2: ORANGE_NEON_R07; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
Q4: MPSA42; TO-92_Inline_Wide
R150, R151: TBD_R07_NEON; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
R152: 10k; R_0805_2012Metric
R153: 100k; R_0805_2012Metric

Connections:
COLON_BASE: Q4.2 (B), R152.2, R153.1
COLON_ENABLE: J31.2, R152.1
GND: J31.1, Q4.1 (E), R153.2
HV_RAW: J30.1, R150.1, R151.1
NEON0_ANODE: NE1.1, R150.2
NEON1_ANODE: NE2.1, R151.2
NEON_CATHODES: NE1.2, NE2.2, Q4.3 (C)

Notes on the sheet:
橙色ネオン2灯・個別電流制限
ネオン各枝に独立抵抗。維持/始動電圧・暗所特性と抵抗定格はR07で確認。HVと信号のコネクターは分離済み。
同名のネットラベルは階層を越えて接続。未確定値/TBDは発注不可。端子配置はSources欄を参照。

Board: 2 copper layers, 16.0 x 60.0 mm, 11 parts (7 on the bottom side), 7 nets.

Other parts of the board:
H1, H2: NPTH_DRAFT; MountingHole_2.2mm_M2

## KiCad design hardware/pcb/generated_display/display-board.kicad_pcb

Notes on the sheet:
JJY / IN-12B ×4 / Arduino Nano 5V / DS3231
レビュー用初版：HV電圧・K155ID1保護・部品/ソケット現物・コネクター定格は未確定。通電・発注不可。
機械寸法の正本：enclosure/layout.json。制御基板は候補配置・現物未照合。HV回路は別基板・保留。

Notes on the sheet:
電源・保護・HV停止制御
市販絶縁12V DCのみ。JP1を外してUSB書込。JP2は通常未挿入。HV部はR01/R02/R06未解決・通電不可。
同名のネットラベルは階層を越えて接続。未確定値/TBDは発注不可。端子配置はSources欄を参照。

Parts:
C100: 100n_50V; C_0805_2012Metric
D100, D101, D102, D103, D104, D105, D106, D107, D108, D109: CLAMP_DIODE_100V_R02; D_SOD-123
J10: DIGIT0_LOGIC; PinHeader_1x06_P2.54mm_Vertical
J20: DIGIT0_HV_GUARDED; PhoenixContact_MSTBVA_2,5_2-G-5,08_1x02_P5.08mm_Vertical
R100: 18k_0.5W_R01_CANDIDATE; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R101: 1M_0.25W_HV; R_Axial_DIN0309_L9.0mm_D3.2mm_P5.08mm_Vertical
U10: K155ID1_R02_HOLD; DIP-16_W7.62mm
V1: IN-12B_SOCKET_R04; IN-12B_Socket_Candidate
Z10: ZENER_47V_R02; D_SOD-123

Connections:
+5V: C100.1, J10.1, U10.5 (VCC)
BCD0_0: J10.3, U10.3 (X1/1)
BCD0_1: J10.4, U10.6 (X2/2)
BCD0_2: J10.5, U10.7 (X3/4)
BCD0_3: J10.6, U10.4 (X4/8)
DIGIT0_ANODE: R100.2, V1.1 (ANODE)
DIGIT0_CLAMP: D100.1 (K), D101.1 (K), D102.1 (K), D103.1 (K), D104.1 (K), D105.1 (K), D106.1 (K), D107.1 (K), D108.1 (K), D109.1 (K), Z10.1 (K)
DIGIT0_K0: D100.2 (A), U10.16 (Y0), V1.2 (K0)
DIGIT0_K1: D101.2 (A), U10.15 (Y1), V1.11 (K1)
DIGIT0_K2: D102.2 (A), U10.8 (Y2), V1.10 (K2)
DIGIT0_K3: D103.2 (A), U10.9 (Y3), V1.9 (K3)
DIGIT0_K4: D104.2 (A), U10.13 (Y4), V1.8 (K4)
DIGIT0_K5: D105.2 (A), U10.14 (Y5), V1.7 (K5)
DIGIT0_K6: D106.2 (A), U10.11 (Y6), V1.6 (K6)
DIGIT0_K7: D107.2 (A), U10.10 (Y7), V1.5 (K7)
DIGIT0_K8: D108.2 (A), U10.1 (Y8), V1.4 (K8)
DIGIT0_K9: D109.2 (A), U10.2 (Y9), V1.3 (K9)
GND: C100.2, J10.2, J20.2, R101.2, U10.12 (GND), Z10.2 (A)
HV_RAW: J20.1, R100.1, R101.1

Notes on the sheet:
表示子1・IN-12Bソケット候補
R01/R02未閉：HV200V候補と47Vクランプは計算上の候補で未実測。接続検討図であり通電・発注用ではない。
同名のネットラベルは階層を越えて接続。未確定値/TBDは発注不可。端子配置はSources欄を参照。
