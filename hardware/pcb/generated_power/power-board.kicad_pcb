# Repository nexus4812/nixie-jjy-clock (continued)

## KiCad design hardware/pcb/generated_display/display-board.kicad_pcb (continued)

Board: 2 copper layers, 34.0 x 54.0 mm, 22 parts (17 on the bottom side), 19 nets.

Other parts of the board:
H1, H2, H3, H4: NPTH_DRAFT; MountingHole_3.2mm_M3

## KiCad design hardware/pcb/generated/control-board.kicad_pcb

Notes on the sheet:
JJY / IN-12B ×4 / Arduino Nano 5V / DS3231
レビュー用初版：HV電圧・K155ID1保護・部品/ソケット現物・コネクター定格は未確定。通電・発注不可。
機械寸法の正本：enclosure/layout.json。制御基板は候補配置・現物未照合。HV回路は別基板・保留。

Parts:
C3: 47u_16V; CP_Radial_D5.0mm_P2.00mm
C4: 100n_50V; C_0805_2012Metric
J41: EXTERNAL_5V_BUCK; PinHeader_1x02_P2.54mm_Vertical
J42: LV_CONTROL_ONLY; PinHeader_1x03_P2.54mm_Vertical
JP1: REMOVE_FOR_USB; PinHeader_1x02_P2.54mm_Vertical

Connections:
5V_BUCK: J41.1, JP1.1
+5V: C3.1, C4.1, JP1.2; also elsewhere on the board
COLON_ENABLE: J42.3; also elsewhere on the board
GND: C3.2, C4.2, J41.2, J42.1; also elsewhere on the board
HV_ENABLE: J42.2; also elsewhere on the board

Notes on the sheet:
電源・保護・HV停止制御
市販絶縁12V DCのみ。JP1を外してUSB書込。JP2は通常未挿入。HV部はR01/R02/R06未解決・通電不可。
同名のネットラベルは階層を越えて接続。未確定値/TBDは発注不可。端子配置はSources欄を参照。

Parts:
A1: NANO_328P_5V16MHz; Arduino_Nano
C10, C11: 100n_50V; C_0805_2012Metric
C12: 10u_16V; C_0805_2012Metric
J50: TO_DIGIT0_LV; PinHeader_1x06_P2.54mm_Vertical
J51: TO_DIGIT1_LV; PinHeader_1x06_P2.54mm_Vertical
J52: TO_DIGIT2_LV; PinHeader_1x06_P2.54mm_Vertical
J53: TO_DIGIT3_LV; PinHeader_1x06_P2.54mm_Vertical
R10, R11, R12: 100R; R_0805_2012Metric
R13, R14: 10k; R_0805_2012Metric
U1, U2: 74HCT595D; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+5V: A1.27 (5V), C10.1, C11.1, C12.1, J50.1, J51.1, J52.1, J53.1, U1.10 (~SRCLR), U1.16 (VCC), U2.10 (~SRCLR), U2.16 (VCC); also elsewhere on the board
BCD0_0: J50.3, U1.15 (Q0)
BCD0_1: J50.4, U1.1 (Q1)
BCD0_2: J50.5, U1.2 (Q2)
BCD0_3: J50.6, U1.3 (Q3)
BCD1_0: J51.3, U1.4 (Q4)
BCD1_1: J51.4, U1.5 (Q5)
BCD1_2: J51.5, U1.6 (Q6)
BCD1_3: J51.6, U1.7 (Q7)
BCD2_0: J52.3, U2.15 (Q0)
BCD2_1: J52.4, U2.1 (Q1)
BCD2_2: J52.5, U2.2 (Q2)
BCD2_3: J52.6, U2.3 (Q3)
BCD3_0: J53.3, U2.4 (Q4)
BCD3_1: J53.4, U2.5 (Q5)
BCD3_2: J53.5, U2.6 (Q6)
BCD3_3: J53.6, U2.7 (Q7)
BUTTON_MINUS: A1.21 (A2); also elsewhere on the board
BUTTON_PLUS: A1.20 (A1); also elsewhere on the board
BUTTON_SET: A1.19 (A0); also elsewhere on the board
COLON_ENABLE: A1.10 (D7); also elsewhere on the board
GND: A1.4 (GND), A1.29 (GND), C10.2, C11.2, C12.2, J50.2, J51.2, J52.2, J53.2, R13.2, R14.2, U1.8 (GND), U1.13 (~OE), U2.8 (GND), U2.13 (~OE); also elsewhere on the board
HV_ENABLE: A1.9 (D6); also elsewhere on the board
I2C_SCL: A1.24 (A5); also elsewhere on the board
I2C_SDA: A1.23 (A4); also elsewhere on the board
JJY_DATA: A1.5 (D2); also elsewhere on the board
PDN1_PULL_LOW: A1.7 (D4); also elsewhere on the board
PDN2_PULL_LOW: A1.8 (D5); also elsewhere on the board
RTC_SQW: A1.6 (D3); also elsewhere on the board
SR_CASCADE: U1.9 (Q7S), U2.14 (SER)
SR_CLOCK: A1.16 (D13), R10.1
SR_CLOCK_BUS: R10.2, R13.1, U1.11 (SRCLK), U2.11 (SRCLK)
SR_DATA: A1.14 (D11), R12.1
SR_DATA_BUS: R12.2, U1.14 (SER)
SR_LATCH: A1.13 (D10), R11.1
SR_LATCH_BUS: R11.2, R14.1, U1.12 (RCLK), U2.12 (RCLK)
STATUS_LED: A1.12 (D9); also elsewhere on the board

Notes on the sheet:
Arduino Nano・16bit静的BCD駆動
595 OEはGND固定。データをラッチするまでHVを許可しない。D8予備。D0/D1はUSB診断用。
同名のネットラベルは階層を越えて接続。未確定値/TBDは発注不可。端子配置はSources欄を参照。

Parts:
BT1: Keystone 1060; BatteryHolder_Keystone_1060_1x2032
C20: 100n_50V; C_0805_2012Metric
J3: I2C_TEST; PinHeader_1x04_P2.54mm_Vertical
R20, R21: 4k7; R_0805_2012Metric
R22: 10k; R_0805_2012Metric
U3: DS3231SN#; SOIC-16W_7.5x10.3mm_P1.27mm

Connections:
+5V: C20.1, J3.1, R20.1, R21.1, R22.1, U3.2 (VCC); also elsewhere on the board
GND: BT1.2 (-), C20.2, J3.2, U3.5 (N.C._GND), U3.6 (N.C._GND), U3.7 (N.C._GND), U3.8 (N.C._GND), U3.9 (N.C._GND), U3.10 (N.C._GND), U3.11 (N.C._GND), U3.12 (N.C._GND), U3.13 (GND); also elsewhere on the board
I2C_SCL: J3.4, R21.2, U3.16 (SCL); also elsewhere on the board
I2C_SDA: J3.3, R20.2, U3.15 (SDA); also elsewhere on the board
RTC_SQW: R22.2, U3.3 (INT/SQW); also elsewhere on the board
VBAT: BT1.1 (+), U3.14 (VBAT)

Notes on the sheet:
DS3231・非充電バックアップ
DS3231S/SN。N.C.の5〜12番はGND。CR2032は充電しない。RST外部プルアップなし。
同名のネットラベルは階層を越えて接続。未確定値/TBDは発注不可。端子配置はSources欄を参照。

Parts:
C30: 10u_16V; C_0805_2012Metric
C31, C33, C34: 100n_50V; C_0805_2012Metric
C32: 1u_EFFECTIVE_MIN; C_0805_2012Metric
J4: JJY_DIAGNOSTIC; PinHeader_1x03_P2.54mm_Vertical
J45: TO_EXTERNAL_JJY; PinHeader_1x05_P2.54mm_Vertical
Q2, Q3: MPSA42; TO-92_Inline_Wide
R30: 100R; R_0805_2012Metric
R31: 1k; R_0805_2012Metric
R32, R33, R35, R36: 47k; R_0805_2012Metric
R34, R37: 100k; R_0805_2012Metric
U4: MCP1700-3002E/TO; TO-92_Inline_Wide
U5: SN74HCT125D; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+3V_JJY: C32.1, C33.1, J45.1, R32.1, R35.1, U4.3 (VOUT)
+5V: C34.1, R30.1, U5.4 (~OE2), U5.10 (~OE3), U5.13 (~OE4), U5.14 (VCC); also elsewhere on the board
GND: C30.2, C31.2, C32.2, C33.2, C34.2, J4.1, J45.2, Q2.1 (E), Q3.1 (E), R34.2, R37.2, U4.1 (GND), U5.1 (~OE1), U5.5 (A2), U5.7 (GND), U5.9 (A3), U5.12 (A4); also elsewhere on the board
JJY_DATA: J4.3, U5.3 (Y1); also elsewhere on the board
JJY_LDO_IN: C30.1, C31.1, R30.2, U4.2 (VIN)
JJY_OUT_BUFFER_IN: R31.2, U5.2 (A1)
JJY_OUT_RAW: J4.2, J45.4, R31.1
JJY_PDN1: J45.5, Q2.3 (C), R32.2
JJY_PDN2: J45.3, Q3.3 (C), R35.2
PDN1_BASE: Q2.2 (B), R33.2, R34.1
PDN1_PULL_LOW: R33.1; also elsewhere on the board
PDN2_BASE: Q3.2 (B), R36.2, R37.1
PDN2_PULL_LOW: R36.1; also elsewhere on the board

Notes on the sheet:
JJY 3V電源・40/60kHz選局・µA出力バッファ
H/H停止。Nano D4=HighでPDN1をLow、D5=HighでPDN2をLow。RAW OUTへプルアップやLEDを接続しない。
同名のネットラベルは階層を越えて接続。未確定値/TBDは発注不可。端子配置はSources欄を参照。

Parts:
C40, C41, C42: 100n_50V; C_0805_2012Metric
J40: REAR_UI_HARNESS; PinHeader_1x05_P2.54mm_Vertical
R40: 1k; R_0805_2012Metric
R41, R42, R43: 10k; R_0805_2012Metric

Connections:
+5V: R41.1, R42.1, R43.1; also elsewhere on the board
BUTTON_MINUS: C42.1, J40.4, R43.2; also elsewhere on the board
BUTTON_PLUS: C41.1, J40.3, R42.2; also elsewhere on the board
BUTTON_SET: C40.1, J40.2, R41.2; also elsewhere on the board
GND: C40.2, C41.2, C42.2, J40.1; also elsewhere on the board
LED_ANODE: J40.5, R40.2
STATUS_LED: R40.1; also elsewhere on the board

Notes on the sheet:
背面操作・JJY状態表示
SET / + / -。状態LEDの点滅はファームウェアで定義。共有位置データはenclosure/layout.json。
同名のネットラベルは階層を越えて接続。未確定値/TBDは発注不可。端子配置はSources欄を参照。
